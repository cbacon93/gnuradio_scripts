<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>baudrate</value></param>
<param><key>value</key><value>70e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decimation</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/Users/marcel/demod1</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_unpacked_to_packed_xx</key>
<param><key>id</key><value>blocks_unpacked_to_packed_xx_0</value></param>
<param><key>bits_per_chunk</key><value>2</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_psk_demod</key>
<param><key>id</key><value>digital_psk_demod_0</value></param>
<param><key>differential</key><value>True</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>freq_bw</key><value>6.28/100.0</value></param>
<param><key>mod_code</key><value>"none"</value></param>
<param><key>constellation_points</key><value>4</value></param>
<param><key>phase_bw</key><value>6.28/100.0</value></param>
<param><key>samples_per_symbol</key><value>int(samp_rate/decimation/baudrate)</value></param>
<param><key>timing_bw</key><value>6.28/100.0</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>0</value></param>
<param><key>decim</key><value>decimation</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>taps</key><value>firdes.low_pass_2(4,samp_rate,5e3,1e2,40)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate/decimation</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>freqchangevar</key><value>None</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>rtlsdr_source</key>
<param><key>id</key><value>rtlsdr_source_0</value></param>
<param><key>bb_gain0</key><value>50</value></param>
<param><key>dc_offset_mode0</key><value>2</value></param>
<param><key>corr0</key><value>54</value></param>
<param><key>freq0</key><value>131.725e6</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>if_gain0</key><value>50</value></param>
<param><key>iq_balance_mode0</key><value>2</value></param>
<param><key>gain0</key><value>50</value></param>
<param><key>args</key><value></value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_unpacked_to_packed_xx_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_demod_0</source_block_id><sink_block_id>blocks_unpacked_to_packed_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>digital_psk_demod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rtlsdr_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
